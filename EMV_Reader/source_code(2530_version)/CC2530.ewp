# IAR project CC2530.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: Source\Board; Source\Prt; Source
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256.xcl
configuration Release (8051)
  as the first configuration, except:
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCIncludePath2: E:\我的程序\2530\Source\Board; E:\我的程序\2530\Source\Prt; E:\我的程序\2530\Source
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256.xcl
  group (top)
    Source/: ioCC2530.h main.c myMacros.h types.h
  group Board
    Source/Board/: basic_rf.c basic_rf.h board.c board.h clock.c clock.h clrc663.c clrc663.h hal_rf.c hal_rf.h led.c led.h myOs.c
